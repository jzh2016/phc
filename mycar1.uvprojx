# Keil uVision project mycar1.uvprojx, settings and files
target MyBalanceCar (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mycar1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\HARD\TIMER;.\HARD\ENCODER;.\HARD\MOTOR;.\HARD\LED;.\BALANCE\CONTROL;.\SYS;.\HARD\show;.\HARD\OLED;.\BALANCE\DMP;.\HARD\MPU6050;.\HARD\IIC;.\SYS\usart;.\HARD\USART3;.\HARD\EXTI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: MAIN.C
  group HARD
    ./HARD/ENCODER/: ENCODER.C
    ./HARD/LED/: LED.C
    ./HARD/MOTOR/: MOTOR.C
    ./HARD/TIMER/: TIMER.C
    ./HARD/OLED/: oled.c
    ./HARD/show/: show.c
    ./HARD/MPU6050/: MPU6050.c
    ./HARD/IIC/: IOI2C.c
    ./HARD/EXTI/: exti.c
  group SYS
    ./SYS/: sys.c delay.c
    ./SYS/usart/: usart.c
  group BALANCE
    ./BALANCE/CONTROL/: CONTROL.C
    ./BALANCE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group ::Device
    D:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.1.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s stm32f10x_conf.h system_stm32f10x.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
